Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:47+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-212-0350
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-212-0350 Тематический игровой комплекс «Американские горки»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Американские горки»; Classification: 59.1.15.01-0242 Горка (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-212-0350; ModelReference: Тематический игровой комплекс «Американские горки»; ProductionYear: 2026; ArticleNumber: ZSK-212-0350
ORION_Изделие - Артикул: ZSK-212-0350; Артикул прежний: SD-212-0350; Наименование: Тематический игровой комплекс «Американские горки»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 17.1 x 8.8 м; Зона безопасности: 21.0 x 12.5 м; Высота свободного падения: 1.8 м; Возраст: для детей от 2 до 12 лет; Цена: 16 016 880 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/themed/3004; Код КСИ: CPr>EDB030; Класс КСИ: Горка; Коды КСР: 59.1.15.01-0242 … 59.1.15.01-0305
ADSK - ADSK_Наименование: Тематический игровой комплекс «Американские горки»; ADSK_Марка: ZSK-212-0350; ADSK_Код изделия: 59.1.15.01-0242; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/themed/3004
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 21.0 x 12.5 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB030; ZSK_Артикул_прежний: SD-212-0350
Qto_ORION - Длина: 17100 mm; Ширина: 8800 mm; Высота: 0 mm
